# Keil uVision project EndDevice.uvprojx, settings and files
target EndDevice (5060020::V5.06 (build 20)::ARMCC)
  device: STM32L476RGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.1.0.0
  cpu: IRAM(0x20000000-0x20017FFF) IRAM2(0x10000000-0x10007FFF) IROM(0x8000000-0x80FFFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: EndDevice +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L476xx
  c misc: --C99
  c include: ../Inc;              ../Drivers/STM32L4xx_HAL_Driver/Inc;              ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy;              ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;              ../Middlewares/Third_Party/FreeRTOS/Source/include;              ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;              ../Drivers/CMSIS/Include;              ../Drivers/CMSIS/Device/ST/STM32L4xx/Include;              ..\mbed_lib\XBeeLib;              ..\mbed_lib\XBeeLib\DigiLogger;              ..\mbed_lib\XBeeLib\FrameBuffer;              ..\mbed_lib\XBeeLib\FrameHandlers;              ..\mbed_lib\XBeeLib\Frames;              ..\mbed_lib\XBeeLib\IO;              ..\mbed_lib\XBeeLib\RemoteXBee;              ..\mbed_lib\XBeeLib\Utils;              ..\mbed_lib\XBeeLib\XBee;              ..\mbed_lib\XBeeLib\XBee802;              ..\mbed_lib\XBeeLib\XBeeDM;              ..\mbed_lib\XBeeLib\XBeeZB;              ..\mbed_lib\mbed;              ..\mbed_lib\mbed\TARGET_STM32L4;              ..\mbed_lib\mbed\TARGET_STM32L4\TARGET_NUCLEO_L476RG;              .;              XBeeLib;              XBeeLib/FrameBuffer;              XBeeLib/FrameHandlers;              XBeeLib/Frames;              XBeeLib/IO;              XBeeLib/RemoteXBee;              XBeeLib/Utils;              XBeeLib/XBee;              XBeeLib/XBee802;              XBeeLib/XBeeDM;              XBeeLib/XBeeZB;              XBeeLib/DigiLogger;              mbed/;              mbed/TARGET_NUCLEO_L476RG;              mbed/TARGET_NUCLEO_L476RG/TARGET_STM;              mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4;              mbed/TARGET_NUCLEO_L476RG/TARGET_STM/TARGET_STM32L4/TARGET_NUCLEO_L476RG;              mbed/TARGET_NUCLEO_L476RG/TOOLCHAIN_ARM_STD
  asm include: ..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  link misc: --diag_suppress=L6329
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
    ../Middlewares/Third_Party/FreeRTOS/Source/: timers.c event_groups.c list.c queue.c tasks.c croutine.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group Application/MDK-ARM
    ./: startup_stm32l476xx.s
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal_adc_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_i2c.c stm32l4xx_hal_flash.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_adc.c stm32l4xx_hal_cortex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_tim.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_pwr.c stm32l4xx_hal_rtc.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32L4xx/Source/Templates/: system_stm32l4xx.c
  group Application/User
    ../Src/: stm32l4xx_hal_timebase_TIM.c freertos.c stm32l4xx_it.c stm32l4xx_hal_msp.c water_pump.c main.c aqua_tasks.c util_func.c task_manager.c water_flow.c garden_tasks.c xbee_test.c am2302.c soil_moisture.c ultrasonic.c
software components: CMSIS:CORE 4.1.0
